inherit obmc-phosphor-image-puti