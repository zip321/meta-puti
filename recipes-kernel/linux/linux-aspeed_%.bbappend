FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Kernel-DT-customizations-for-Puti-platform.patch"

