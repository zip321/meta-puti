FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Adapt-x86-power-control-to-Puti-paltform.patch"

