IMAGE_INSTALL:append = " \
        pld-manager \
        "